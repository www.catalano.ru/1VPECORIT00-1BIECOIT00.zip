Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Ceramica-Catalano_Italy-52-Eco-Floorstanding-NewFlush-WC.ifc
Time: 2020-06-17T12:44:36
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Italy 52 Eco Floorstanding NewFlush WC
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Italy 52 Eco Floorstanding NewFlush WC; SKU (BO_prodsku): catalano_wc_italy_NF_52_eco_floor_cod_1VPECORIT00; ManufacturName (BO_Manufac): Ceramica Catalano; BrandUrl (BO_brandurl): http://www.catalano.it/; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/ceramica-catalano/product/catalano_wc_italy_NF_52_eco_floor_cod_1VPECORIT00; ProductDataUrl (BO_prodaturl): bimobject.com/ceramica-catalano/product/catalano_wc_italy_NF_52_eco_floor_cod_1VPECORIT00; MaterialMain (BO_mainmat): Ceramics; MaterialSecondary (BO_secmat): Vitreous china; IfcClassification (BO_ifcclas): Sanitary Terminal; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
